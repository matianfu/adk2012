# IAR project usb_device_dfu_isp.ewp, settings and files
configuration Release (AVR32)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32allahf.h
  General.GSStackSize: 0x0400
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=DUMMY_BOARD
  ICCAVR32.CCIncludePath2: ..\; ..\..\; ..\..\..\; ..\..\..\..\..\..\..\..\..\..\..\avr32\utils\; ..\..\..\..\..\..\..\..\..\..\..\avr32\utils\preprocessor\; ..\..\..\..\..\..\..\..\..\..\..\common\utils\; ..\..\..\..\..\..\..\..\..\..\..\common\boards\; ..\..\..\..\..\..\..\..\..\..\..\avr32\boards\; ..\..\..\..\..\..\..\..\..\..\..\avr32\drivers\gpio\; ..\..\..\..\..\..\..\..\..\..\..\avr32\drivers\pm\; ..\..\..\..\..\..\..\..\..\..\..\avr32\drivers\scif\; ..\..\..\..\..\..\..\..\..\..\..\avr32\drivers\ast\; ..\..\..\..\..\..\..\..\..\..\..\avr32\drivers\flashc\; ..\..\..\..\..\..\..\..\..\..\..\avr32\drivers\rtc\; ..\..\..\..\..\..\..\..\..\..\..\avr32\drivers\cpu\cycle_counter\; ..\..\..\..\..\..\..\..\..\..\..\avr32\drivers\usbc\; ..\..\..\..\..\..\..\..\..\..\..\common\services\basic\clock\; ..\..\..\..\..\..\..\..\..\..\..\avr32\services\basic\freq_detect\; ..\..\..\..\..\..\..\..\..\..\..\common\services\usb\; ..\..\..\..\..\..\..\..\..\..\..\common\services\usb\udc\; ..\..\..\..\..\..\..\..\..\..\..\common\services\usb\class\dfu\; ..\..\..\..\..\..\..\..\..\..\..\common\services\usb\class\dfu\device\; ..\..\..\..\..\..\..\..\..\..\..\common\services\usb\class\dfu\device\atmel\
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=DUMMY_BOARD
  AAVR32.AIncludePaths: ..\; ..\..\; ..\..\..\; ..\..\..\..\..\..\..\..\..\..\..\avr32\utils\; ..\..\..\..\..\..\..\..\..\..\..\avr32\utils\preprocessor\; ..\..\..\..\..\..\..\..\..\..\..\common\utils\
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnkat32uc3c-isp.xcl
  group (top)
    ../../: boot.s82 intc.c isp.c main.c
    ../: sysclk_uc3c.c
  group drivers
    ../../../../../../../../../../../avr32/drivers/ast/: ast.c
    ../../../../../../../../../../../avr32/drivers/flashc/: flashc.c
    ../../../../../../../../../../../avr32/drivers/pm/: pm_uc3c.c
    ../../../../../../../../../../../avr32/drivers/scif/: scif_uc3c.c
    ../../../../../../../../../../../avr32/drivers/usbc/: usbc_device.c
  group services/basic
    ../../../../../../../../../../../avr32/services/basic/freq_detect/: freq_detect.c
  group services/usb/class/dfu
    ../../../../: udi_dfu_atmel.c udi_dfu_atmel_desc.c
  group services/usb/udc
    ../../../../../../../../udc/: udc.c
