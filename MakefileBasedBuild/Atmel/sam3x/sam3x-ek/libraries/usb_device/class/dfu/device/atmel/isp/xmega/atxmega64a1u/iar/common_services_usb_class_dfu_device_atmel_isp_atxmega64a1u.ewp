# IAR project common_services_usb_class_dfu_device_atmel_isp_atxmega64a1u.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: __ATxmega128A1U__; BOARD=DUMMY_BOARD
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ..\..\..\..\..\..\..\..\..\..\..\xmega\drivers\cpu; .; ..\..\..\..\..\..\..\..\..\..\..\xmega\boards\dummy; ..\..\..\..\..\..\..\..\..\..\..\xmega\utils; ..\..\..\..\..\..\..\..\..\..\..\xmega\drivers\nvm; ..\..\..\..\..\..\..\..\..\..\..\xmega\drivers\usb; ..; ..\..\..\..\..\..\..\..\..\..\..\xmega\boards; ..\..\..\..; ..\..\..\..\..\..\..\..\..\..\utils; ..\..\..\..\..\..\..\..\..\clock; ..\..\..\..\..\..\..\..; ..\..\..\..\..\..\..\..\udc; ..\..; ..\..\..\..\..\..\..\..\..\..\boards; ..\..\..\..\..\..\..\..\..\..\..\xmega\utils\preprocessor; ..\..\..\..\..\..
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=DUMMY_BOARD
  XLINK.XclFile: test_on_atxmega128a1_boot.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=DUMMY_BOARD
  XLINK.XclFile: atxmega64a1_boot.xcl
  group (top)
    ../../../../../../../../../../../xmega/drivers/cpu/: ccp.s
    ./: cstartup.s90
    ../../: isp.c main.c
    ../../../../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
    ../../../../../../../../../clock/xmega/: sysclk.c
    ../: sysclk_opt.c udc_opt.c
    ../../../../../../../../udc/: udc.c
    ../../../../: udi_dfu_atmel.c udi_dfu_atmel_desc.c
    ../../../../../../../../../../../xmega/drivers/usb/: usb_device.c
